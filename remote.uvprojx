# Keil uVision project remote.uvprojx, settings and files
target remote (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: remote +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\src\core;.\src\StartUp;.\src\Lib\inc;.\src\Lib\src;.\src\driver;.\src\bsp;.\src\control;.\src\app;.\src\include;.\src\FreeRTOS\include;.\src\FreeRTOS;.\src\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./src/StartUp/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group core
    ./src/core/: main.c init.c delay.c
    ./src/include/: all_data.h all_define.h
  group library
    ./src/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group driver
    ./src/driver/: adc.c i2c.c spi.c tim.c
  group bsp
    ./src/bsp/: nrf24l01.c eeprom.c buzzer.c key.c
  group control
    ./src/control/: rc_protocol.c remote.c
  group app
    ./src/app/: app_tasks.c task_rc.c task_input.c task_storage.c task_buzzer.c task_monitor.c freertos_hooks.c
  group FreeRTOS
    ./src/FreeRTOS/: tasks.c queue.c list.c
    ./src/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./src/FreeRTOS/portable/MemMang/: heap_4.c
